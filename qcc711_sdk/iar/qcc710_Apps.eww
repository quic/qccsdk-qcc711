<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\apps\appsGeneral.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\apps\appsPeripheral.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libBLE.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libCMSIS.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libCrypto.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libPeripheral.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libPlatform.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libQCLI.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Apps - Debug</name>
            <member>
                <project>libBLE</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCMSIS</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCrypto</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPeripheral</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPlatform</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libQCLI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>appsGeneral</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>appsPeripheral</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Libraries - Release</name>
            <member>
                <project>libBLE</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCMSIS</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCrypto</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPeripheral</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPlatform</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libQCLI</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Apps - Release</name>
            <member>
                <project>libBLE</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCMSIS</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCrypto</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPeripheral</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPlatform</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libQCLI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>appsGeneral</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>appsPeripheral</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
