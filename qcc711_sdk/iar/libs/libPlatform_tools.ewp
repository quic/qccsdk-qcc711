# IAR project libPlatform_tools.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.IExtraOptions: -DDISABLE_VDIO_FAULT_HANDLER
  ICCARM.CCIncludePath2: ..\..\common\crypto\inc; ..\..\common\tmecom\api; ..\..\qapi\ble; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\platform; ..\..\qapi\peripherals; ..\..\src\ble\inc; ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\common\crypto\inc; ..\..\src\common\temcom\inc; ..\..\src\hwio\inc; ..\..\src\peripherals\inc; ..\..\src\platform\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group inc
    ../../src/platform/inc/: ram.h stringl.h
  group src
    ../../src/platform/src/: qapi_debug.c qapi_heap.c qapi_mfg.c qapi_nvm.c qapi_power.c qapi_radio.c qapi_task.c qapi_wdog.c ram.c stringl.c
