# IAR project libBLE.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\ble\inc; ..\..\src\crypto\inc; ..\..\src\hwio\inc; ..\..\src\platform\inc; ..\..\qapi\ble; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\platform; ..\..\qapi\peripherals
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group inc
    ../../src/ble/inc/: BASAPI_cb_m3.h BASAPI_cb_params.h BASAPI_params.h BSCAPI_cb_m3.h BSCAPI_cb_params.h BSCAPI_params.h callback.h DISAPI_cb_m3.h DISAPI_cb_params.h DISAPI_params.h GAPAPI_cb_m3.h GAPAPI_cb_params.h GAPAPI_mnl_util.h GAPAPI_params.h GAPSAPI_cb_m3.h GAPSAPI_cb_params.h GAPSAPI_params.h GATTAPI_cb_m3.h GATTAPI_cb_params.h GATTAPI_params.h HCIAPI_cb_m3.h HCIAPI_cb_params.h HCIAPI_params.h id_list.h ipc.h ipc_types.h L2CAPAPI_cb_m3.h L2CAPAPI_cb_params.h L2CAPAPI_mnl_util.h L2CAPAPI_params.h qipc.h
  group src
    ../../src/ble/src/: BASAPI_cb_m3.c BASAPI_funcs_m3.c BSCAPI_cb_m3.c BSCAPI_funcs_m3.c BSCAPI_funcs_m3_mnl.c callback.c DISAPI_cb_m3.c DISAPI_funcs_m3.c DISAPI_funcs_m3_mnl.c DTM_funcs_m3_mnl.c GAPAPI_cb_m3.c GAPAPI_cb_m3_mnl.c GAPAPI_funcs_m3.c GAPAPI_funcs_m3_mnl.c GAPSAPI_cb_m3.c GAPSAPI_funcs_m3.c GAPSAPI_funcs_m3_mnl.c GATTAPI_cb_m3.c GATTAPI_cb_m3_mnl.c GATTAPI_funcs_m3.c GATTAPI_funcs_m3_mnl.c HCI_VS_API_funcs_m3_mnl.c HCIAPI_cb_m3.c HCIAPI_funcs_m3.c HCIAPI_funcs_m3_mnl.c ipc.c L2CAPAPI_cb_m3.c L2CAPAPI_cb_m3_mnl.c L2CAPAPI_funcs_m3.c L2CAPAPI_funcs_m3_mnl.c qipc.c
