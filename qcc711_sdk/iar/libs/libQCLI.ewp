# IAR project libQCLI.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\ble\inc; ..\..\src\hwio\inc; ..\..\src\platform\inc; ..\..\qapi\platform; ..\..\qapi\common; ..\..\qapi\peripherals
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group inc
    ../../src/demo/qcli/: qcli.h qcli_api.h qcli_pal.h qcli_util.h
  group src
    ../../src/demo/qcli/: qcli.c qcli_pal.c qcli_util.c
