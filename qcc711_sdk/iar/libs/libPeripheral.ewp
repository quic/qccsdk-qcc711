# IAR project libPeripheral.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ENABLE_PERIPHERAL_SPI; ENABLE_PERIPHERAL_I2C; ENABLE_PERIPHERAL_UART
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\hwio\inc; ..\..\src\peripherals\inc; ..\..\qapi\common; ..\..\qapi\peripherals; ..\..\qapi\platform; ..\..\qapi\crypto
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group inc
    ../../src/peripherals/inc/: qspi.h qspi_map.h qup_api.h qup_hwio.h timer.h
  group src
    ../../src/peripherals/src/: qapi_appi2c.c qapi_duc.c qapi_flash.c qapi_ftc.c qapi_gpio.c qapi_i2c.c qapi_led.c qapi_m2mdma.c qapi_sense.c qapi_spi.c qapi_timer.c qapi_uart.c qspi.c qspi_map.c qup_api.c qup_se_fw.c timer.c
