# IAR project libCMSIS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\hwio\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group inc
    ../../src/CMSIS/Core/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm3.h
    ../../src/CMSIS/Device/QC/QCC710/Include/: qcc710.h system_qcc710.h
  group src
    ../../src/CMSIS/Device/QC/QCC710/Source/IAR/: startup_qcc710.s
    ../../src/CMSIS/Device/QC/QCC710/Source/: system_qcc710.c
