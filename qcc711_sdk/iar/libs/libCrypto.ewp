# IAR project libCrypto.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: GLINK_CFG_MAX_REMOTE_HOSTS=1; GLINK_CFG_MAX_NOTIFY_CBS=1
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\qapi\ble; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\peripherals; ..\..\qapi\platform; ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\common\crypto\inc; ..\..\src\common\mproc\glink\inc; ..\..\src\common\mproc\inc; ..\..\src\common\temcom\inc; ..\..\src\common\temfuse\inc; ..\..\src\crypto\inc; ..\..\src\hwio\inc; ..\..\src\platform\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group inc
    ../../qapi/crypto/: qapi_crypto.h qapi_crypto_common.h qapi_firmware_update.h qapi_fuse.h qapi_rot.h
  group src
    ../../src/common/mproc/glink/src/: glink_api.c xport_qmp.c
    ../../src/tmeipc/: glink_os_dal.c TmecomClientCfg.c TmecomClientOsApis.c xport_qmp_config.c
    ../../src/crypto/src/: qapi_crypto.c qapi_crypto_cmn.c qapi_firmware_update.c qapi_fuse.c tme_ipc_access_control.c tme_ipc_crypto.c tme_ipc_fwup.c tme_ipc_msg_uid_mapping.c tme_ipc_nvm_utils.c tme_ipc_rot_feature.c tme_ipc_utils.c tme_ipc_callback_utils.c tme_ipc_crypto_cmn.c tme_ipc_msg_uid_mapping_cmn.c tme_ipc_nvm_cmn.c
    ../../src/common/temcom/src/: qapi_rot.c qapi_rot_feature.c TmecomClient.c
    ../../src/common/temfuse/src/: TmeFuseClient.c TmeFusePlatformApis.c
