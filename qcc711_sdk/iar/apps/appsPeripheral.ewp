# IAR project appsPeripheral.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\demo\general\ble; ..\..\src\demo\general\crypto; ..\..\src\demo\peripherals\epd; ..\..\src\demo\peripherals\flash; ..\..\src\demo\peripherals\ftc; ..\..\src\demo\peripherals\gpio; ..\..\src\demo\peripherals\i2c; ..\..\src\demo\peripherals\m2mdma; ..\..\src\demo\peripherals\mfp; ..\..\src\demo\peripherals\sensor_duc; ..\..\src\demo\peripherals\smps; ..\..\src\demo\peripherals\spi; ..\..\src\demo\peripherals\timer; ..\..\src\demo\peripherals\uart; ..\..\src\demo\peripherals\wdog; ..\..\src\demo\qcli; ..\..\src\platform\inc; ..\..\qapi\ble; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\peripherals; ..\..\qapi\platform; ..\..\src\demo\peripherals\appi2c; ..\..\src\demo\peripherals\flash
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\src\CMSIS\Device\QC\QCC710\Source\IAR\iar_arm.icf
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libBLE.a; ..\libs\Release\Exe\libCMSIS.a; ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe\libPlatform.a; ..\libs\Release\Exe\libQCLI.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ../../src/demo/peripherals/: sample_periph.c
  group appi2c
    ../../src/demo/peripherals/appi2c/: appi2c_demo.c appi2c_demo.h
  group epd
    ../../src/demo/peripherals/epd/: epd_demo.c epd_demo.h
  group flash
    ../../src/demo/peripherals/flash/: flash_demo.c flash_demo.h
  group ftc
    ../../src/demo/peripherals/ftc/: ftc_demo.c ftc_demo.h
  group gpio
    ../../src/demo/peripherals/gpio/: gpio_demo.c gpio_demo.h
  group i2c
    ../../src/demo/peripherals/i2c/: i2c_demo.c i2c_demo.h
  group m2mdma
    ../../src/demo/peripherals/m2mdma/: m2mdma_demo.c m2mdma_demo.h
  group mfp
    ../../src/demo/peripherals/mfp/: mfp_demo.c mfp_demo.h
  group sensor_duc
    ../../src/demo/peripherals/sensor_duc/: sensor_duc_demo.c sensor_duc_demo.h
  group smps
    ../../src/demo/peripherals/smps/: smps_demo.c smps_demo.h
  group spi
    ../../src/demo/peripherals/spi/: spi_demo.c spi_demo.h
  group timer
    ../../src/demo/peripherals/timer/: timer_demo.c timer_demo.h
  group uart
    ../../src/demo/peripherals/uart/: uart_demo.c uart_demo.h
  group wdog
    ../../src/demo/peripherals/wdog/: wdog_demo.c wdog_demo.h
