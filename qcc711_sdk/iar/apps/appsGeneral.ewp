# IAR project appsGeneral.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\demo\general\ble; ..\..\src\demo\general\crypto; ..\..\src\demo\general\platform; ..\..\src\demo\qcli; ..\..\src\platform\inc; ..\..\qapi\ble; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\peripherals; ..\..\qapi\platform
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: appsGeneral.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\src\CMSIS\Device\QC\QCC710\Source\IAR\iar_arm.icf
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libBLE.a; ..\libs\Release\Exe\libCMSIS.a; ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe\libPlatform.a; ..\libs\Release\Exe\libQcli.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libBLE.a; ..\libs\Release\Exe\libCMSIS.a; ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe\libPlatform.a; ..\libs\Release\Exe\libQCLI.a
  group (top)
    ../../src/demo/general/: sample_gen.c
  group ble/inc
    ../../src/demo/general/ble/: bas_demo.h ble_demo.h
  group ble/src
    ../../src/demo/general/ble/: bas_demo.c ble_demo.c
  group crypto/inc
    ../../src/demo/general/crypto/: crypto_demo.h fwup_demo.h rot_demo.h rot_demo_utils.h
  group crypto/src
    ../../src/demo/general/crypto/: crypto_demo.c fwup_demo.c rot_demo.c rot_demo_utils.c
  group platform/inc
    ../../src/demo/general/platform/: mfg_demo.h nvm_demo.h plat_demo.h
  group platform/src
    ../../src/demo/general/platform/: mfg_demo.c nvm_demo.c plat_demo.c
