<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\tools\toolsBLE_DTM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tools\toolsFlashLoader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tools\toolsNVMProgrammer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tools\toolsOTP.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tools\toolsQCC710Programmer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tools\toolsSecureLoader.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libBLE.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libCMSIS.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libCrypto.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libPeripheral.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libPlatform.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libPlatform_tools.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\libs\libQCLI.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Tools - Debug</name>
            <member>
                <project>libBLE</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCMSIS</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCrypto</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPeripheral</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPlatform</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPlatform_tools</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libQCLI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>toolsBLE_DTM</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>toolsFlashLoader</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>toolsNVMProgrammer</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>toolsOTP</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>toolsSecureLoader</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>toolsQCC710Programmer</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Tools - Release</name>
            <member>
                <project>libBLE</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCMSIS</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libCrypto</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPeripheral</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPlatform</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libPlatform_tools</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>libQCLI</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>toolsFlashLoader</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>toolsNVMProgrammer</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>toolsOTP</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>toolsSecureLoader</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>toolsQCC710Programmer</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
