# IAR project toolsNVMProgrammer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\hwio\inc; ..\..\qapi\platform; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\peripherals
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: toolsGDBProgrammer.srec
  ILINK.IlinkOutputFile: nvm_programmer.out
  ILINK.IlinkIcfFile: ..\..\src\CMSIS\Device\QC\QCC710\Source\IAR\iar_arm_ram.icf
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libCMSIS.a; ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe_tools\libPlatform_tools.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe_tools\libPlatform_tools.a
  group (top)
    ../../tools/src/: nvm_programmer.c
