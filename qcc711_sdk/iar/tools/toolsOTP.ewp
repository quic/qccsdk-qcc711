# IAR project toolsOTP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\hwio\inc; ..\..\qapi\platform; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\peripherals
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: otp_tool.out
  ILINK.IlinkIcfFile: ..\..\src\CMSIS\Device\QC\QCC710\Source\IAR\iar_arm_ram.icf
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libBLE.a; ..\libs\Release\Exe\libCMSIS.a; ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe_tools\libPlatform_tools.a; ..\libs\Release\Exe\libQcli.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: opt_tool.out
  group (top)
    ../../tools/src/: otp_tool.c
