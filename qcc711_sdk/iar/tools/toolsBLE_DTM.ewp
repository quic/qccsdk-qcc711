# IAR project toolsBLE_DTM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCIncludePath2: ..\..\src\ble\inc; ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\qapi\ble; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\peripherals; ..\..\qapi\platform
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ble_dtm.hex
  ILINK.IlinkOutputFile: ble_dtm.out
  ILINK.IlinkIcfFile: ..\..\src\CMSIS\Device\QC\QCC710\Source\IAR\iar_arm.icf
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libBLE.a; ..\libs\Release\Exe\libCMSIS.a; ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe_tools\libPlatform_tools.a; ..\libs\Release\Exe\libQcli.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group (top)
    ../../tools/src/: ble_dtm.c
