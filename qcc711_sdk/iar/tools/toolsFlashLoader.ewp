# IAR project toolsFlashLoader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $EW_DIR$\arm\src\flashloader\framework2; $EW_DIR$\arm\src\flashloader\framework2\template; ..\..\src\CMSIS\Core\Include; ..\..\src\CMSIS\Device\QC\QCC710\Include; ..\..\src\common\crypto\inc; ..\..\src\common\temcom\inc; ..\..\src\common\temfuse\inc; ..\..\src\hwio\inc; ..\..\qapi\platform; ..\..\qapi\common; ..\..\qapi\crypto; ..\..\qapi\peripherals
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: qcc710_Loader.out
  ILINK.IlinkIcfFile: ..\..\tools\src\qcc710_flash_loader.icf
  ILINK.IlinkAdditionalLibs: ..\libs\Release\Exe\libCrypto.a; ..\libs\Release\Exe\libPeripheral.a; ..\libs\Release\Exe_tools\libPlatform_tools.a
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pe186
  ICCARM.CCOptLevel: 3
  group (top)
    ../../tools/src/: flash_loader_asm.s flash_loader_ram.c
  group framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c
